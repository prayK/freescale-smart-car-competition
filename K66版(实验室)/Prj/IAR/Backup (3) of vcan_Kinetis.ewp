# IAR project Backup (3) of vcan_Kinetis.ewp, settings and files
configuration MK66FX18_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG_MODE; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCIncludePath2: ..\..\App; ..\..\App\Inc; ..\..\Board\Inc; ..\..\Chip\inc; ..\..\Chip\inc\IAR; ..\..\Chip\inc\kinetis; ..\..\Lib\CMSIS\Inc; ..\..\Lib\FatFs; ..\..\Lib\USB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: vcan_Kinetis.bin
  ILINK.IlinkOutputFile: vcan_Kinetis.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K66X1M.icf
  ILINK.IlinkAdditionalLibs: ..\..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MK66FX18_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; ARM_MATH_CM4; MK66F18; MK66FX18; FPU_USED
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: vcan_Kinetis.srec
  group App
    ../../App/: enter.h ImageDeal.c ImageDeal.h ImageInformation.c ImageInformation.h main.c MK66_conf.c ModulesInit.c ModulesInit.h MyLibrary.c MyLibrary.h OLED.c OLED.h ServoControl.c ServoControl.h SmartCarControl.c SmartCarControl.h
    ../../App/Inc/: include.h MK66_conf.h PORT_cfg.h
    ../../: 备注.c
  group Board
    ../../Board/src/: CAMERA.C COMMUNICATION.C KEY.C LCD_ST7735S.C LED.C OV7725_EAGLE.C SCCB.C
    ../../Board/inc/: CAMERA.H COMMUNICATION.H KEY.H LCD_ST7735S.H LED.H OV7725_EAGLE.H OV7725_REG.H SCCB.H
  group Chip
    ../../Chip/inc/: common.h misc.h MK66_adc.h MK66_dma.h MK66_flexbus.h MK66_gpio.h MK66_gpio_cfg.h MK66_i2c.h MK66_port.h MK66_rtc.h MK66_sdhc.h MK66_spi.h MK66_uart.h MK66_wdog.h vectors.h
    ../../Chip/src/: misc.c MK66_adc.c MK66_dma.c MK66_flexbus.c MK66_gpio.c MK66_i2c.c MK66_port.c MK66_rtc.c MK66_sdhc.c MK66_spi.c MK66_uart.c MK66_wdog.c vectors.c
    ../../Chip/src/IAR/: startup_MK66FX18.s system_MK66FX18.c
