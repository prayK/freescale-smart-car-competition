# IAR project 1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: App; App\Inc; Board\inc; Chip\inc; Chip\inc\IAR; Chip\inc\kinetis; Lib\CMSIS\Inc; Lib\FatFs; Lib\USB; C:\Users\ManBa\Desktop\620\App
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: 1.out
  ILINK.IlinkIcfFile: Prj\IAR\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: Board\inc; Board\src; Chip\src; C:\Users\ManBa\Desktop\622\Chip\inc
  ICCARM.CCOptLevel: 3
  group App
    App/: car_control.c main.c main_menu.c MK60_conf.c MK60_it.c Speed_Control.c
    Board/src/: imag.c init.c
    App/Inc/: include.h MK60_conf.h MK60_it.h PORT_cfg.h
    ./: ProLog.c
  group Board
    Board/src/: Board_Gyro.c VCAN_ASCII.c VCAN_camera.c VCAN_computer.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_OV7725_Eagle.c VCAN_SCCB.c VCAN_UI_VAR.c
    Board/inc/: Board_Gyro.h
    App/: VCAN_menu.c
  group Chip
    Chip/inc/: common.h
    Chip/src/: misc.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
    Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
