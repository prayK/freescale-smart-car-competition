# IAR project Backup of myProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 Freescale MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MKV58F1M0VLL24; FSL_RTOS_BM; SDK_OS_BAREMETAL; NDEBUG
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../devices/MKV58F24/iar; ..\..\..\..\../devices/MKV58F24; ..\..\..\..\../devices/MKV58F24/utilities; ..\..\..\..\../devices/MKV58F24/drivers; ..\..\..\..\../CMSIS/Include; ../../..; ../; F:\kv58NXP\SDK_2.2_TWR-KV58F220M\boards\twrkv58f220m\user_apps\myProject20170714ch
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: myProject.srec
  ILINK.IlinkOutputFile: myProject.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\../devices/MKV58F24/iar; ..\..\..\..\../devices/MKV58F24; ..\..\..\..\../devices/MKV58F24/utilities; ..\..\..\..\../devices/MKV58F24/drivers; ..\..\..\..\../CMSIS/Include; ../../..; ../
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MKV58F1M0xxx24_flash.icf
  group board
    ../: board.c board.h bsp_my_oled.c bsp_oled.c Camera.c clock_config.c clock_config.h direction.c dma.c gpio.c gpio.h i2c.c it.c key_group.c mpu6050.c ov7725.c picture_deal.c pin_mux.c pin_mux.h speed.c upstand.c
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../../../../../devices/MKV58F24/: fsl_device_registers.h MKV58F24.h MKV58F24_features.h system_MKV58F24.c system_MKV58F24.h
  group drivers
    ../../../../../devices/MKV58F24/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_hsadc.c fsl_hsadc.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_rcm.c fsl_rcm.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_trng.c fsl_trng.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group sources
    ../: main.c
  group startup
    ../../../../../devices/MKV58F24/iar/: startup_MKV58F24.s
  group utilities
    ../../../../../devices/MKV58F24/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h
