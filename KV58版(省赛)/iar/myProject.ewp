# IAR project myProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV58F1M0xxx24 Freescale MKV58F1M0xxx24
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MKV58F1M0VLL24; FSL_RTOS_BM; SDK_OS_BAREMETAL; NDEBUG
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../devices/MKV58F24/iar; ..\..\..\..\../devices/MKV58F24; ..\..\..\..\../devices/MKV58F24/utilities; ..\..\..\..\../devices/MKV58F24/drivers; ..\..\..\..\../CMSIS/Include; ../../..; ../; F:\kv58NXP\SDK_2.2_TWR-KV58F220M\boards\twrkv58f220m\user_apps\myProject20170714ch
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: myProject.srec
  ILINK.IlinkOutputFile: myProject.out
  ILINK.IlinkIcfFile: MKV58F1M0xxx24_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\..\../devices/MKV58F24/iar; ..\..\..\..\../devices/MKV58F24; ..\..\..\..\../devices/MKV58F24/utilities; ..\..\..\..\../devices/MKV58F24/drivers; ..\..\..\..\../CMSIS/Include; ../../..; ../
  ICCARM.CCOptLevel: 3
  group (top)
    ./: MKV58F1M0xxx24_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dma.c dma.h gpio.c gpio.h i2c.c i2c.h pin_mux.c pin_mux.h
  group CMSIS
    ../: cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group drivers
    ../: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_debug_console.c fsl_debug_console.h fsl_device_registers.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_lptmr.c fsl_lptmr.h fsl_pit.c fsl_pit.h fsl_port.h fsl_pwm.c fsl_pwm.h fsl_shell.c fsl_shell.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_wdog.c fsl_wdog.h
  group sources
    ../: bsp_my_oled.c bsp_my_oled.h bsp_oled.c bsp_oled.h Camera.c Camera.h ImageInformation.c ImageInformation.h include.h key.c key.h main.c ov7725.c ov7725.h ServoControl.c ServoControl.h speed.c speed.h
  group startup
    ../: startup_MKV58F24.s system_MKV58F24.c system_MKV58F24.h
